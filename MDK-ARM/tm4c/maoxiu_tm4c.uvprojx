# Keil uVision project maoxiu_tm4c.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C1233H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: xingshu
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ../../Lib/src;./Lib;./User;../../platform/tm4c/bsp/inc;RTE/RTOS;../../services/tm4c_legacy/inc;./MathTools;../../drivers/tm4c/inc;../../services/protocol;../../services;../../algorithms/chassis;../../platform/tm4c;../../app/tm4c;../../drivers/tm4c;../../boards/tm4c;../../Lib/src;../../Lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USR
    ../../app/tm4c/: main.c FreeRTOS.c
  group LIB
    ../../Lib/src/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group BSP
    ../../platform/tm4c/bsp/src/: bsp_gpio.c bsp_iic.c bsp_spi.c bsp_tim.c bsp_uart.c bsp_adc.c
  group Peripheral_Proc
    ../../services/tm4c_legacy/src/: key_proc.c lcd_proc.c mpu6050_proc.c rgb_proc.c servo_proc.c buzzer_proc.c
  group MathTools
    ../../algorithms/tm4c_legacy/: WP_Math.c
  group Peripheral_Proc/Diver
    ../../drivers/tm4c/src/: lcd.c lcd_init.c mpu6050.c
  group maoxiu shared services
    ../../services/protocol/: star_protocol.c star_dispatch.c
    ../../algorithms/chassis/: chassis_math.c
    ../../services/: chassis_service.c
    ../../app/tm4c/: control_task.c pc_service.c
    ../../drivers/tm4c/: maoxiu_motor.c
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.5.1, Device:Startup 1.0.1
